Commit message: feat: simulation sync

File: ic_arm/urdf/ic_arm.urdf (robot description, URDF)
Before this commit: robot ic_arm, 12 links, 11 joints
Joints:
- joint m3-l4: axis 0 1 0 -> 0 -1 0
- joint m4-l5: axis 0 1 0 -> 0 -1 0
- joint m5-l6: axis 0 0 1 -> 0 0 -1
